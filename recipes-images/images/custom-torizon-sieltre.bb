SUMMARY = "Sieltre SMARC TDX IMX95"
DESCRIPTION = "Siel Tre Custom Image for IMX95 Platform BOX/Postazione"
LICENSE = "MIT"

inherit core-image

SYSTEMD_DEFAULT_TARGET = "multi-user.target"

IMAGE_LINGUAS = "en-us"
